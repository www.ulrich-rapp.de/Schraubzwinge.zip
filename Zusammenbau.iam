# Autodesk Inventor assembly: Zusammenbau
## iProperties
Created: 2009-11
Part Number: Zusammenbau
Document SubType Name: Assembly
Designer: user
Author: user
